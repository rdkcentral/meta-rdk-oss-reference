CFLAGS:append:wrynose += " \
    -Wno-error=implicit-function-declaration \
    -Wno-error=return-mismatch \
"
