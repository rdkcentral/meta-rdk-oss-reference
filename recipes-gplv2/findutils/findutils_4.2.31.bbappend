#https://lists.yoctoproject.org/g/yocto/topic/meta_gplv2_patch_1_2/69604792
EXTRA_OECONF += " ac_cv_func_working_mktime=yes"
