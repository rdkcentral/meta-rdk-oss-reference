
SRC_URI:append = " file://0001-vulkan-registry-path-prefix.patch"
SRC_URI:append = " file://0002-vkmark-build.patch"
SRC_URI:append = " file://0003-vkmark-wayland-gbm-swapchain-queue-workarounds.patch"
