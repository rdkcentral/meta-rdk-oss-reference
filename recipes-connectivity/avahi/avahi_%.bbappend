SYSTEMD_AUTO_ENABLE_${PN}-daemon = "disable"
RRECOMMENDS_avahi-daemon_remove = " libnss-mdns"
