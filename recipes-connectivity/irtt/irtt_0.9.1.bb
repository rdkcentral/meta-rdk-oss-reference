SUMMARY = "irtt network testing tool (wrynose dependency stub)"
DESCRIPTION = "Isochronous Round-Trip Time — a network latency and jitter measurement tool"
LICENSE = "GPL-2.0-only"
LIC_FILES_CHKSUM = "file://${COMMON_LICENSE_DIR}/GPL-2.0-only;md5=801f80980d171dd6425610833a22dbe6"

PV = "0.9.1"
PR = "r0"

ALLOW_EMPTY:${PN} = "1"
