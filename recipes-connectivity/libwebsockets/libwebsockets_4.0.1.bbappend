FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-RDK-54515-Fix-missing-dependency-in-packageconfig.patch"

