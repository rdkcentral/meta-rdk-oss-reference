FILESEXTRAPATHS:prepend := "${THISDIR}/files_516:"

SRC_URI:append = " file://0001-idle_metrics_v2.patch "
