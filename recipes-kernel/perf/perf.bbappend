
RDEPENDS:${PN}:remove += "elfutils "

