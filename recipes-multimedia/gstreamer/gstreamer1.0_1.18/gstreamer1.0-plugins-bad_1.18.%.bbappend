PACKAGECONFIG:append = " opusparse"
PACKAGECONFIG:remove = "hls"
