PACKAGECONFIG:remove = "giflib"
