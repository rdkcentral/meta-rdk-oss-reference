DEPENDS:remove = "${@bb.utils.contains('PACKAGECONFIG','qt5','qtsvg','',d)}"