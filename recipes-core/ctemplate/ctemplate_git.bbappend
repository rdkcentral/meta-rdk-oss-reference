PACKAGE_BEFORE_PN += "${PN}-extras"

FILES:${PN}-extras = "${libdir}/libctemplate_nothreads.so*"
