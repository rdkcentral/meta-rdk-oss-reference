# Add MLPREFIX to support oss arch with multilib support
SRC = "${COMPONENTS_DIR}/${PACKAGE_ARCH}/${MLPREFIX}glibc-stash-locale/scripts"
