RDEPENDS_packagegroup-meta-oe-bsp_remove = "pointercal"
RDEPENDS_packagegroup-meta-oe-graphics_remove = "tslib"
RDEPENDS_packagegroup-meta-oe-connectivity_remove = "libuv"
RDEPENDS_packagegroup-meta-oe-devtools_remove = "giflib"
