RDEPENDS:${PN}:remove = "nativesdk-bison nativesdk-autoconf nativesdk-automake"
