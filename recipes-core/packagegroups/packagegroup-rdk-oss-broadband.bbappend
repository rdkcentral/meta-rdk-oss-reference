# rsync is GPL-3.0 excluded
RDEPENDS:packagegroup-rdk-oss-broadband:remove:wrynose = "rsync"
