RDEPENDS:${PN}:remove = "netbase"
