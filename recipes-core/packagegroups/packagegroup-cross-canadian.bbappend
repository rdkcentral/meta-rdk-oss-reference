GDB = ""
GCC = ""
BINUTILS = ""
do_package[vardeps] += "GDB GCC BINUTILS"
