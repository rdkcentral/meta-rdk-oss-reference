FILESEXTRAPATHS_prepend := "${THISDIR}/glib-2.0:"

SRC_URI += " \
           file://0001-glib-gmessages-UTC.patch \
"
