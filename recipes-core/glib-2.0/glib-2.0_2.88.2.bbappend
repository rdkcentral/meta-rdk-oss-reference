FILESEXTRAPATHS:prepend := "${THISDIR}/glib-2.0:"

SRC_URI:append = " file://0001-gdbus-codegen-guard-GLib-2.84-version-macro.patch"
