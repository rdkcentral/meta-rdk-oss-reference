PACKAGECONFIG:remove = "vconsole logind"
RDEPENDS:${PN}:remove:wrynose = "util-linux-mkswap"
