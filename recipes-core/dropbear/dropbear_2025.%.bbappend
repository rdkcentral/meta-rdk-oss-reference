FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"
SRC_URI:append:wrynose = " file://wrynose_authkeys.patch "
