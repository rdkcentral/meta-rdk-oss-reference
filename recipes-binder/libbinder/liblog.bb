DESCRIPTION = "RDK Android liblog module"
