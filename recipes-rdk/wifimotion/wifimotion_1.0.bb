SUMMARY = "WiFi motion (wrynose dependency stub)"
LICENSE = "CLOSED"
PV = "1.0"
PR = "r0"

ALLOW_EMPTY:${PN} = "1"
