# To support ipk consumption in MW
RPROVIDES:${PN} = " drm"
