
DEBUG_FLAGS_dunfell = "-g -feliminate-unused-debug-types"
