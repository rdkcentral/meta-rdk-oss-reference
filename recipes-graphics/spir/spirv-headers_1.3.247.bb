require spirv-headers.inc

PV = "1.3.247"
# sdk-1.3.246.1 tag is the upstream drop published alongside Vulkan SDK 1.3.247
SRCREV = "1feaf4414eb2b353764d01d88f8aa4bcc67b60db"
