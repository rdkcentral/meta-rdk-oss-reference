require spirv-headers.inc

PV = "1.3.260"
# PV tracks the Vulkan SDK version (1.3.260); the SPIR-V headers are taken from
# the sdk-1.3.261.1 tag, which is the closest Khronos drop compatible with 1.3.260.
SRCREV = "124a9665e464ef98b8b718d572d5f329311061eb"
