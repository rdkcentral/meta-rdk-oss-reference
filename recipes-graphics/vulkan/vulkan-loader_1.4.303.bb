require recipes-graphics/vulkan/vulkan-loader.inc

SRCREV = "ce2d68b24b66a91ed798d870ca205f899ee6e79d"
PV = "1.4.303"
