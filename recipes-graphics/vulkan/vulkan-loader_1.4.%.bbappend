
RRECOMMENDS:${PN}:remove = "virtual-vulkan-icd"

PACKAGE_ARCH = "${OSS_LAYER_ARCH}"
