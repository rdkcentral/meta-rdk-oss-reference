require vulkan-tools.inc

SRCREV = "adf8532bc503066a9c4cf8ea30cc0f8217044f0f"
PV = "1.3.260"

SRC_URI += "file://0001-Disable-xdg-wm-base-related-code.patch"
