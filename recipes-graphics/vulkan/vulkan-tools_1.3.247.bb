require vulkan-tools.inc

SRCREV = "8bb9edd13f5027b6676f5229cb4a1822050b1f36"
PV = "1.3.247"

SRC_URI += "file://0001-Disable-xdg-wm-base-related-code.patch"
