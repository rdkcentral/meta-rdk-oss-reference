require vulkan-loader.inc

SRCREV = "5bc25766b0fa8cd17d4f1f112a5c58828997cf81"
PV = "1.3.260"
