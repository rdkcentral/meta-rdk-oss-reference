require vulkan-validationlayers.inc
LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=cd3c0bc366cd9b6a906e22f0bcb5910f"

SRCREV = "d366f9f0ca1177eeb907e73d40081802581fc7ae"
PV = "1.3.260"
