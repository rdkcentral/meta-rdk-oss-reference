require vulkan-headers.inc

LIC_FILES_CHKSUM = "file://LICENSES/Apache-2.0.txt;md5=3b83ef96387f14655fc854ddc3c6bd57"

SRCREV = "94bb3c998b9156b9101421f7614617dfcf7f4256"
PV = "1.3.260"

PACKAGES := "${PN} ${PN}-dev"
