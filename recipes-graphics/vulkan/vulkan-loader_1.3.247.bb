require vulkan-loader.inc

SRCREV = "797ffe01088e61daa9d12c3810e0bbaa9652558a"
PV = "1.3.247"
