require recipes-graphics/vulkan/vulkan-validationlayers.inc

SRCREV = "3bcff29a3fc1644ac86a494da61301f8cdce3ab5"
PV = "1.4.303"
