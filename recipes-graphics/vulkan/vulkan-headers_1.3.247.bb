require vulkan-headers.inc

LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=3b83ef96387f14655fc854ddc3c6bd57"

SRCREV = "95a13d7b7118d3824f0ef236bb0438d9d51f3634"
PV = "1.3.247"

PACKAGES := "${PN} ${PN}-dev"
