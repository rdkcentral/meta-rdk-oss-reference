FILES:${PN}-dev += "${datadir}/pkgconfig/wayland-protocols.pc"
