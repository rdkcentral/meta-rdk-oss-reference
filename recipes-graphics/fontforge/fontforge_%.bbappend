DEPENDS_remove += "giflib"
