PACKAGECONFIG_remove = "cairo"
