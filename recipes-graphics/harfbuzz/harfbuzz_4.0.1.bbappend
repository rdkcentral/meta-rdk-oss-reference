PACKAGECONFIG:remove = "cairo"
