FILES:${PN} += "${libdir}/libgdbm_compat.so*"

