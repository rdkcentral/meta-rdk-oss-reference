FILESEXTRAPATHS:prepend := "${THISDIR}/${BP}:"

PACKAGECONFIG += "make-icudata"
