FILESEXTRAPATHS:prepend := "${THISDIR}/files:"


SRC_URI:append = " file://CVE-2025-57052_1.7.15_fix.patch"
