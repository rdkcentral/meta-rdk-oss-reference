FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

# header_installation.patch: pkginclude_HEADERS already in libevent 2.1.12+ upstream, patch obsolete
