FILESEXTRAPATHS:prepend := "${THISDIR}/${BPN}:"

SRC_URI += "file://0003-copy-mime-xml-with-legacy-gettext.patch"