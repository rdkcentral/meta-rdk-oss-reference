FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI += "file://nanomsg-size.patch"