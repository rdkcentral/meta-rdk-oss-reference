FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI:append:broadband = " file://CVE-2023-36321_2.18_fix.patch "
