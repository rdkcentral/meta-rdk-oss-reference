#As the sqlite3-dev is provided by the libsqlite3-dev
RPROVIDES_lib${BPN}-dev = "${PN}-dev"
