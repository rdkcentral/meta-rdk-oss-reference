FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += " file://CVE-2025-6965_3.38.5_fix.patch \
	   "

