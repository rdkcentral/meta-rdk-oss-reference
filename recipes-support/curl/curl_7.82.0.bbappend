FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI:append = " file://CVE-2024-11053_7.82.0_fix.patch \
                   file://CVE-2025-0167_7.82.0_fix.patch \
                   file://CVE-2025-14524_7.82.0_fix.patch \
                   file://CVE-2025-15079_7.82.0_fix.patch \
                   file://CVE-2025-15224_7.82.0_fix.patch \
                   file://CVE-2026-1965_7.82.0_fix.patch \
                   file://CVE-2026-3783_7.82.0_fix.patch \
                   file://CVE-2026-3784_7.82.0_fix.patch \
                   file://CVE-2026-4873_7.82.0_fix.patch \
                   file://CVE-2026-5545_7.82.0_fix.patch \
                   file://CVE-2026-5773_7.82.0_fix.patch \
                   file://CVE-2026-6253_7.82.0_fix.patch \
                   file://CVE-2026-6276_7.82.0_fix.patch \
                   file://CVE-2026-6429_7.82.0_fix.patch \
                   file://CVE-2026-7168_7.82.0_fix.patch \
"
