PACKAGE_BEFORE_PN += "${PN}-extras"
FILES:${PN}-extras = " \
    ${bindir}/libevdev-tweak-device \
    ${bindir}/touchpad-edge-detector \
    ${bindir}/mouse-dpi-tool \
"
