PACKAGE_BEFORE_PN += "${PN}-extras"
FILES:${PN}-extras = " \
    ${bindir}/yat2m \
"
