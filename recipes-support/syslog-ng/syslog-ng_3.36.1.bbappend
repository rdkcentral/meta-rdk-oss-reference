FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += " file://CVE-2022-38725_3.36_fix.patch "
