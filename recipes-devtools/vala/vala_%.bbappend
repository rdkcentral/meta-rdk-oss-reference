GI_GIRDIR:class-target = "${libdir}/gir-1.0"
export GI_GIRDIR
