FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI:append:class-target = " file://0001-GDBM_File-match-fatal-callback-prototype.patch"