RDEPENDS_${PN}_remove_class-native ="perl perl-modules"
BBCLASSEXTEND = "native"
