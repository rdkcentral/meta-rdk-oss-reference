I_SWEAR_TO_MIGRATE_TO_PYTHON3 = "yes"
