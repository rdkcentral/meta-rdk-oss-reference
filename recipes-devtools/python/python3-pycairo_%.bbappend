DEPENDS_append = " virtual/egl"
