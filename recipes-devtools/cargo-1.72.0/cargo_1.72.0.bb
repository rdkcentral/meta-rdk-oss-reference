require recipes-devtools/rust-1.72.0/rust-source-${PV}.inc
require recipes-devtools/rust-1.72.0/rust-snapshot-${PV}.inc
require cargo.inc
BBCLASSEXTEND = "native nativesdk"
