RDEPENDS:${PN}:remove = "nativesdk-elfutils"
RDEPENDS:${PN} += "nativesdk-libelf nativesdk-libdw"
