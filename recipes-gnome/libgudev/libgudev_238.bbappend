FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI:append = " file://libgudev-udev-230-compat.patch"