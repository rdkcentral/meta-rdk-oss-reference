FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI += "file://bash_log.patch \
            file://CVE-2012-3410.patch \
            file://CVE-2016-0634.patch \
            "
